# Keil uVision project RS485-IO.uvprojx, settings and files
target RS485-IO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RS485-IO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Drivers/user_dev;..\Drivers\user_dev;..\appl;..\Drivers\modbus\include;..\Drivers\modbus\port;..\Drivers\modbus\ascii;..\Drivers\modbus\functions;..\Drivers\modbus\rtu;..\Drivers\modbus\tcp;..\appl\cmd
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c timers.c croutine.c queue.c event_groups.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: stm32f1xx_it.c main.c stm32f1xx_hal_msp.c freertos.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_tim.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_uart.c
  group user_dev
    ../Drivers/user_dev/: dev_printf.c dev_printf.h dev_RS485.c dev_RS485.h dev_sys_clk.c dev_sys_clk.h dev_di.c dev_di.h dev_do.c dev_do.h dev_timer.c dev_timer.h dev_flash.c dev_flash.h dev_port_config.h
  group appl
    ../appl/: platfrom.c platfrom.h modbus_appl.c modbus_appl.h exdoio_appl.c exdoio_appl.h version.h
    ../appl/cmd/: console.c cmd_io.c cmd_io.h cmd_modbus.c cmd_modbus.h cmds.h console.h
  group modbus
    ../Drivers/modbus/ascii/: mbascii.c
    ../Drivers/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Drivers/modbus/port/: portevent.c portserial.c porttimer.c
    ../Drivers/modbus/rtu/: mbcrc.c mbrtu.c
    ../Drivers/modbus/tcp/: mbtcp.c
    ../Drivers/modbus/: mb.c
software components: CMSIS:CORE 5.1.1
